# Keil uVision project FreeRTOS.uvprojx, settings and files
target MK66FX (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: MK66FX1M0xxx18 NXP
  pack: Keil.Kinetis_K60_DFP.1.5.0
  cpu: IRAM(0x20000000,0x00030000) IRAM2(0x1FFF0000,0x00010000) IROM(0x00000000,0x00100000) IROM2(0x10000000,0x00040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Templete
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: __TARGET_FPU_VFP,__FPU_PRESENT=1,ARM_MATH_CM4,_MATH_MATRIX_CHECK,ARM_MATH_ROUNDING
  c include: ..\USER;..\CORE;..\FWLIB\src;..\FWLIB\inc;..\SYSTEM;..\FreeRTOS;..\FreeRTOS\include;..\FreeRTOS\portable\MemMang;..\FreeRTOS\portable\RVDS\ARM_CM4F;..\DSP\Lib\ARM;..\DSP\Include;..\DSP\Source;..\HARDWARE\OLED;..\HARDWARE\LED;..\HARDWARE\KEY;..\HARDWARE\MOTOR;..\HARDWARE\BUZZER;..\HARDWARE\USART;..\HARDWARE\STEERING;..\HARDWARE\Decode;..\HARDWARE\Camera;..\HARDWARE\ADC;..\HARDWARE\AT24C02;..\HARDWARE\IIC
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT5: ROM 0x10000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x1fff0000 size 0x10000
  group USER
    ../USER/: main.c MyTask.c elector.c
    ../FreeRTOS/include/: FreeRTOSConfig.h
    ../FWLIB/inc/: headfile.h
  group SYSTEM
    ../SYSTEM/: isr.c
  group HARDWARE
    ../HARDWARE/OLED/: display.c oled.c
    ../HARDWARE/LED/: led.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/MOTOR/: motor.c
    ../HARDWARE/BUZZER/: buzzer.c
    ../HARDWARE/USART/: usart.c
    ../HARDWARE/STEERING/: steering.c
    ../HARDWARE/Decode/: decode.c
    ../HARDWARE/Camera/: camera.c
    ../HARDWARE/ADC/: adc.c
    ../HARDWARE/AT24C02/: AT24C02.c
    ../HARDWARE/IIC/: SEEKFREE_IIC.c
  group FWLIB
    ../FWLIB/src/: common.c misc.c MK60_adc.c MK60_cmt.c MK60_dac.c MK60_dma.c MK60_flash.c MK60_ftm.c MK60_gpio.c MK60_i2c.c MK60_lptmr.c MK60_pit.c MK60_port.c MK60_rtc.c MK60_sdhc.c MK60_spi.c MK60_systick.c MK60_uart.c MK60_wdog.c
  group CORE
    ../CORE/: core_cm4.h core_cm4_simd.h core_cmFunc.h core_cmInstr.h MK66F18.h startup_MK66F18.s system_MK66.c system_MK66.h
  group FreeRTOS_Core
    ../FreeRTOS/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group FreeRTOS_Portable
    ../FreeRTOS/portable/MemMang/: heap_4.c
    ../FreeRTOS/portable/RVDS/ARM_CM4F/: port.c
  group DSP
    ../DSP/Include/: arm_math.h
    ../DSP/Lib/ARM/: arm_cortexM4lf_math.lib
  group README
    ../README/: Task Functions.c
